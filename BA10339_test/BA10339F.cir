.title KiCad schematic
D12 Net-_D12-Pad1_ Net-_D11-Pad2_ eSim_Diode
I12 Net-_I12-Pad1_ Net-_I1-Pad2_ dc
I15 Net-_D15-Pad1_ Net-_I1-Pad2_ dc
I16 Net-_I16-Pad1_ Net-_I1-Pad2_ dc
D15 Net-_D15-Pad1_ Net-_D15-Pad2_ eSim_Diode
D16 Net-_D16-Pad1_ Net-_D15-Pad2_ eSim_Diode
Q29 GND Net-_D16-Pad1_ Net-_D15-Pad2_ eSim_PNP
Q27 Net-_Q25-Pad1_ Net-_D15-Pad2_ Net-_I12-Pad1_ eSim_PNP
Q21 Net-_Q21-Pad1_ Net-_D11-Pad2_ Net-_I12-Pad1_ eSim_PNP
U1 Net-_Q16-Pad1_ Net-_Q15-Pad1_ Net-_I1-Pad2_ Net-_D6-Pad1_ Net-_D1-Pad1_ Net-_D8-Pad1_ Net-_D2-Pad1_ Net-_D14-Pad1_ Net-_D9-Pad1_ Net-_D16-Pad1_ Net-_D11-Pad1_ GND Net-_Q32-Pad1_ Net-_Q30-Pad1_ PORT
Q22 Net-_Q21-Pad1_ Net-_Q21-Pad1_ GND eSim_NPN
Q19 GND Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_PNP
I10 Net-_D12-Pad1_ Net-_I1-Pad2_ dc
D11 Net-_D11-Pad1_ Net-_D11-Pad2_ eSim_Diode
Q30 Net-_Q30-Pad1_ Net-_I14-Pad1_ GND eSim_NPN
Q28 Net-_I14-Pad1_ Net-_Q23-Pad1_ GND eSim_NPN
Q23 Net-_Q23-Pad1_ Net-_Q18-Pad1_ GND eSim_NPN
Q20 Net-_Q18-Pad1_ Net-_Q18-Pad1_ GND eSim_NPN
Q32 Net-_Q32-Pad1_ Net-_I16-Pad1_ GND eSim_NPN
Q25 Net-_Q25-Pad1_ Net-_Q21-Pad1_ GND eSim_NPN
Q31 Net-_I16-Pad1_ Net-_Q25-Pad1_ GND eSim_NPN
Q26 GND Net-_D14-Pad1_ Net-_D13-Pad2_ eSim_PNP
D14 Net-_D14-Pad1_ Net-_D13-Pad2_ eSim_Diode
D13 Net-_D13-Pad1_ Net-_D13-Pad2_ eSim_Diode
I14 Net-_I14-Pad1_ Net-_I1-Pad2_ dc
I13 Net-_D13-Pad1_ Net-_I1-Pad2_ dc
I11 Net-_I11-Pad1_ Net-_I1-Pad2_ dc
Q24 Net-_Q23-Pad1_ Net-_D13-Pad2_ Net-_I11-Pad1_ eSim_PNP
Q18 Net-_Q18-Pad1_ Net-_D10-Pad2_ Net-_I11-Pad1_ eSim_PNP
Q17 GND Net-_D9-Pad1_ Net-_D10-Pad2_ eSim_PNP
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ eSim_Diode
D9 Net-_D9-Pad1_ Net-_D10-Pad2_ eSim_Diode
I9 Net-_D10-Pad1_ Net-_I1-Pad2_ dc
I6 Net-_D7-Pad1_ Net-_I1-Pad2_ dc
I8 Net-_I8-Pad1_ Net-_I1-Pad2_ dc
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ eSim_Diode
I4 Net-_I4-Pad1_ Net-_I1-Pad2_ dc
I2 Net-_D4-Pad1_ Net-_I1-Pad2_ dc
D4 Net-_D4-Pad1_ Net-_D2-Pad2_ eSim_Diode
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_Diode
Q3 Net-_Q3-Pad1_ Net-_D1-Pad2_ Net-_I3-Pad1_ eSim_PNP
Q8 Net-_Q12-Pad2_ Net-_D5-Pad2_ Net-_I3-Pad1_ eSim_PNP
D3 Net-_D3-Pad1_ Net-_D1-Pad2_ eSim_Diode
I3 Net-_I3-Pad1_ Net-_I1-Pad2_ dc
I1 Net-_D3-Pad1_ Net-_I1-Pad2_ dc
Q11 GND Net-_D6-Pad1_ Net-_D5-Pad2_ eSim_PNP
Q1 GND Net-_D1-Pad1_ Net-_D1-Pad2_ eSim_PNP
Q7 Net-_Q12-Pad2_ Net-_Q3-Pad1_ GND eSim_NPN
Q4 Net-_Q3-Pad1_ Net-_Q3-Pad1_ GND eSim_NPN
D6 Net-_D6-Pad1_ Net-_D5-Pad2_ eSim_Diode
I7 Net-_I7-Pad1_ Net-_I1-Pad2_ dc
I5 Net-_D5-Pad1_ Net-_I1-Pad2_ dc
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ eSim_Diode
Q12 Net-_I7-Pad1_ Net-_Q12-Pad2_ GND eSim_NPN
Q15 Net-_Q15-Pad1_ Net-_I7-Pad1_ GND eSim_NPN
Q9 Net-_Q10-Pad1_ Net-_Q5-Pad1_ GND eSim_NPN
Q6 Net-_Q5-Pad1_ Net-_Q5-Pad1_ GND eSim_NPN
Q2 GND Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_PNP
Q10 Net-_Q10-Pad1_ Net-_D7-Pad2_ Net-_I4-Pad1_ eSim_PNP
Q5 Net-_Q5-Pad1_ Net-_D2-Pad2_ Net-_I4-Pad1_ eSim_PNP
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ eSim_Diode
Q13 GND Net-_D8-Pad1_ Net-_D7-Pad2_ eSim_PNP
D8 Net-_D8-Pad1_ Net-_D7-Pad2_ eSim_Diode
Q14 Net-_I8-Pad1_ Net-_Q10-Pad1_ GND eSim_NPN
Q16 Net-_Q16-Pad1_ Net-_I8-Pad1_ GND eSim_NPN
.end
