.title KiCad schematic
Q29 Net-_Q1-Pad1_ Net-_Q29-Pad2_ Net-_Q27-Pad2_ eSim_PNP
Q27 Net-_Q25-Pad1_ Net-_Q27-Pad2_ Net-_Q21-Pad3_ eSim_PNP
Q21 Net-_Q21-Pad1_ Net-_Q19-Pad3_ Net-_Q21-Pad3_ eSim_PNP
D12 Net-_Q31-Pad1_ Net-_Q19-Pad3_ eSim_Diode
Q19 Net-_Q1-Pad1_ Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_PNP
D11 Net-_Q19-Pad2_ Net-_Q19-Pad3_ eSim_Diode
U1 Net-_Q16-Pad1_ Net-_Q15-Pad1_ Net-_Q31-Pad1_ Net-_Q11-Pad2_ Net-_Q1-Pad2_ Net-_Q12-Pad2_ Net-_Q2-Pad2_ Net-_Q26-Pad2_ Net-_Q17-Pad2_ Net-_Q29-Pad2_ Net-_Q19-Pad2_ Net-_Q1-Pad1_ Net-_Q32-Pad1_ Net-_Q30-Pad1_ PORT
Q31 Net-_Q31-Pad1_ Net-_Q25-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q32 Net-_Q32-Pad1_ Net-_Q31-Pad1_ Net-_Q1-Pad1_ eSim_NPN
D15 Net-_Q31-Pad1_ Net-_Q27-Pad2_ eSim_Diode
D16 Net-_Q29-Pad2_ Net-_Q27-Pad2_ eSim_Diode
Q26 Net-_Q1-Pad1_ Net-_Q26-Pad2_ Net-_Q24-Pad2_ eSim_PNP
Q23 Net-_Q23-Pad1_ Net-_Q18-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q30 Net-_Q30-Pad1_ Net-_Q31-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q28 Net-_Q31-Pad1_ Net-_Q23-Pad1_ Net-_Q1-Pad1_ eSim_NPN
D14 Net-_Q26-Pad2_ Net-_Q24-Pad2_ eSim_Diode
D13 Net-_Q31-Pad1_ Net-_Q24-Pad2_ eSim_Diode
Q25 Net-_Q25-Pad1_ Net-_Q21-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q22 Net-_Q21-Pad1_ Net-_Q21-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q20 Net-_Q18-Pad1_ Net-_Q18-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q18 Net-_Q18-Pad1_ Net-_Q17-Pad3_ Net-_Q18-Pad3_ eSim_PNP
Q17 Net-_Q1-Pad1_ Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_PNP
Q24 Net-_Q23-Pad1_ Net-_Q24-Pad2_ Net-_Q18-Pad3_ eSim_PNP
D9 Net-_Q17-Pad2_ Net-_Q17-Pad3_ eSim_Diode
D10 Net-_Q31-Pad1_ Net-_Q17-Pad3_ eSim_Diode
Q6 Net-_Q5-Pad1_ Net-_Q5-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q9 Net-_Q10-Pad1_ Net-_Q5-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q14 Net-_Q31-Pad1_ Net-_Q10-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q16 Net-_Q16-Pad1_ Net-_Q31-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q13 Net-_Q31-Pad1_ Net-_Q13-Pad2_ Net-_Q1-Pad1_ eSim_NPN
D6 Net-_Q31-Pad1_ Net-_Q10-Pad2_ eSim_Diode
D8 Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_Diode
Q4 Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q7 Net-_Q13-Pad2_ Net-_Q3-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_PNP
D1 Net-_Q1-Pad2_ Net-_Q1-Pad3_ eSim_Diode
Q3 Net-_Q3-Pad1_ Net-_Q1-Pad3_ Net-_Q31-Pad1_ eSim_PNP
Q8 Net-_Q13-Pad2_ Net-_Q11-Pad3_ Net-_Q31-Pad1_ eSim_PNP
Q11 Net-_Q1-Pad1_ Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_PNP
D3 Net-_Q31-Pad1_ Net-_Q1-Pad3_ eSim_Diode
D7 Net-_Q11-Pad2_ Net-_Q11-Pad3_ eSim_Diode
D5 Net-_Q31-Pad1_ Net-_Q11-Pad3_ eSim_Diode
Q15 Net-_Q15-Pad1_ Net-_Q31-Pad1_ Net-_Q1-Pad1_ eSim_NPN
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q31-Pad1_ eSim_PNP
Q12 Net-_Q1-Pad1_ Net-_Q12-Pad2_ Net-_Q10-Pad2_ eSim_PNP
D2 Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_Diode
Q5 Net-_Q5-Pad1_ Net-_Q2-Pad3_ Net-_Q31-Pad1_ eSim_PNP
D4 Net-_Q31-Pad1_ Net-_Q2-Pad3_ eSim_Diode
Q2 Net-_Q1-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ eSim_PNP
.end
