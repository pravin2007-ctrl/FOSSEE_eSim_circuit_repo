.title KiCad schematic
U59 OUT plot_v1
R4 OUT GND 1k
R3 OUT' GND 1k
U57 9_OUT plot_v1
U58 OUT' plot_v1
R2 9_OUT GND 1k
R1 INH_OUT GND 1k
U33 Net-_U13-Pad2_ Net-_U21-Pad2_ Net-_U33-Pad3_ d_and
U34 Net-_U14-Pad2_ Net-_U23-Pad2_ Net-_U34-Pad3_ d_and
U40 Net-_U34-Pad3_ Net-_U12-Pad1_ Net-_U40-Pad3_ d_and
U39 Net-_U33-Pad3_ Net-_U29-Pad6_ Net-_U39-Pad3_ d_and
U36 Net-_U12-Pad2_ Net-_U26-Pad5_ Net-_U36-Pad3_ d_and
U35 Net-_U16-Pad2_ Net-_U25-Pad2_ Net-_U35-Pad3_ d_and
U30 Net-_U29-Pad6_ Net-_U30-Pad2_ d_inverter
U37 Net-_U21-Pad2_ Net-_U29-Pad5_ Net-_U37-Pad3_ d_nand
U42 Net-_U37-Pad3_ Net-_U42-Pad2_ d_inverter
U38 Net-_U30-Pad2_ Net-_U31-Pad2_ Net-_U38-Pad3_ d_and
U43 Net-_U39-Pad3_ Net-_U40-Pad3_ Net-_U43-Pad3_ d_or
U46 Net-_U43-Pad3_ Net-_U44-Pad3_ Net-_U46-Pad3_ d_nor
U50 Net-_U46-Pad3_ Net-_U50-Pad2_ d_inverter
U44 Net-_U36-Pad3_ Net-_U35-Pad3_ Net-_U44-Pad3_ d_or
U54 Net-_U47-Pad2_ Net-_U54-Pad2_ d_inverter
U53 Net-_U52-Pad3_ Net-_U50-Pad2_ Net-_U47-Pad2_ d_and
U52 Net-_U48-Pad2_ Net-_U49-Pad2_ Net-_U52-Pad3_ d_and
U49 Net-_U11-Pad1_ Net-_U49-Pad2_ d_inverter
U47 Net-_U10-Pad1_ Net-_U47-Pad2_ Net-_U47-Pad3_ d_nor
U51 Net-_U47-Pad3_ Net-_U51-Pad2_ d_inverter
U48 Net-_U10-Pad1_ Net-_U48-Pad2_ d_inverter
U56 INH_OUT plot_v1
U55 Net-_U51-Pad2_ Net-_U54-Pad2_ Net-_U42-Pad2_ Net-_U45-Pad2_ OUT OUT' 9_OUT INH_OUT dac_bridge_4
U10 Net-_U10-Pad1_ Net-_U10-Pad2_ d_inverter
U20 Net-_U10-Pad2_ Net-_U19-Pad1_ d_inverter
U19 Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ d_nor
U3 Net-_U10-Pad1_ Net-_U19-Pad2_ d_inverter
U4 Net-_U19-Pad2_ Net-_U10-Pad2_ Net-_U26-Pad4_ d_nand
U11 Net-_U11-Pad1_ Net-_U11-Pad2_ d_inverter
U18 Net-_U11-Pad2_ Net-_U18-Pad2_ d_inverter
U12 Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ d_and
U21 Net-_U12-Pad3_ Net-_U21-Pad2_ Net-_U21-Pad3_ d_nor
U24 Net-_U17-Pad2_ Net-_U21-Pad3_ Net-_U24-Pad3_ d_nor
U28 Net-_U24-Pad3_ Net-_U18-Pad2_ Net-_U19-Pad1_ Net-_U19-Pad3_ Net-_U21-Pad2_ Net-_U25-Pad2_ d_tff
U29 Net-_U25-Pad3_ Net-_U18-Pad2_ Net-_U19-Pad1_ Net-_U19-Pad3_ Net-_U29-Pad5_ Net-_U29-Pad6_ d_tff
U25 Net-_U17-Pad2_ Net-_U25-Pad2_ Net-_U25-Pad3_ d_nor
U1 clock plot_v1
U2 Net-_U2-Pad1_ GND clock Net-_U2-Pad4_ Net-_U10-Pad1_ Net-_U11-Pad1_ adc_bridge_3
v2 clock GND pulse
v1 Net-_U2-Pad1_ GND DC
U27 Net-_U23-Pad3_ Net-_U18-Pad2_ unconnected-_U27-Pad3_ Net-_U26-Pad4_ Net-_U12-Pad1_ unconnected-_U27-Pad6_ d_tff
U26 Net-_U22-Pad3_ Net-_U18-Pad2_ unconnected-_U26-Pad3_ Net-_U26-Pad4_ Net-_U26-Pad5_ Net-_U23-Pad2_ d_tff
U23 Net-_U17-Pad2_ Net-_U23-Pad2_ Net-_U23-Pad3_ d_nor
U22 Net-_U17-Pad2_ Net-_U21-Pad2_ Net-_U22-Pad3_ d_nor
U16 Net-_U16-Pad1_ Net-_U16-Pad2_ d_inverter
U15 Net-_U15-Pad1_ Net-_U12-Pad2_ d_inverter
U17 Net-_U17-Pad1_ Net-_U17-Pad2_ d_inverter
U5 Net-_U2-Pad4_ Net-_U13-Pad1_ d_inverter
U6 Net-_U2-Pad4_ Net-_U14-Pad1_ d_inverter
U13 Net-_U13-Pad1_ Net-_U13-Pad2_ d_inverter
U14 Net-_U14-Pad1_ Net-_U14-Pad2_ d_inverter
U9 Net-_U10-Pad1_ Net-_U17-Pad1_ d_inverter
U8 Net-_U10-Pad1_ Net-_U16-Pad1_ d_inverter
U7 Net-_U2-Pad4_ Net-_U15-Pad1_ d_inverter
U45 Net-_U41-Pad3_ Net-_U45-Pad2_ d_inverter
U41 Net-_U38-Pad3_ Net-_U32-Pad2_ Net-_U41-Pad3_ d_and
U31 Net-_U25-Pad2_ Net-_U31-Pad2_ d_inverter
U32 Net-_U17-Pad2_ Net-_U32-Pad2_ d_inverter
.end
